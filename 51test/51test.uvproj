# Keil uVision project 51test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 51test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_v5\C51\Library;D:\KeilC51\library
  group Source Group 1
    ./: STARTUP.A51 main.c JY901.c ADC.c oled.c AngelADC.c Cylinder.c SetGoal.c
